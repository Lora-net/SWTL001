# Keil uVision project lr11xx-updater-tool.uvprojx, settings and files
target stm32l476rg (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lr11xx-updater-tool
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER, LV_CONF_INCLUDE_SIMPLE, IMAGE_HEADER_FILE=\"lr1110_transceiver_0401.h\"
  c misc: -Wno-deprecated-register
  c include: ..\lr11xx_driver\src;..\external\STM32CubeL4\Drivers\STM32L4xx_HAL_Driver\Inc;..\external\STM32CubeL4\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\external\STM32CubeL4\Drivers\CMSIS\Core\Include;..\external\STM32CubeL4\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\application\inc;..\system\inc;..\display_touch\inc;..\external\lvgl;..\external\lvgl\src;..\external\lvgl\src\lv_core;..\external\lvgl\src\lv_draw;..\external\lvgl\src\lv_font;..\external\lvgl\src\lv_hal;..\external\lvgl\src\lv_misc;..\external\lvgl\src\lv_objx;..\external\lvgl\src\lv_themes;..\lr1110_modem_driver\src;..\lr1121_modem_driver\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group application
    ../application/src/: lr11xx_hal.c lr11xx_firmware_update.c main.c gui.c lr1110_modem_hal.c lr1121_modem_hal.c
  group lr11xx_driver
    ../lr11xx_driver/src/: lr11xx_bootloader.c lr11xx_regmem.c lr11xx_system.c
  group stm32l4xx_hal_driver
    ../external/STM32CubeL4/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_exti.c stm32l4xx_ll_gpio.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_spi.c stm32l4xx_ll_usart.c stm32l4xx_ll_utils.c stm32l4xx_ll_dma.c
  group CMSIS
    ../external/STM32CubeL4/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    ../external/STM32CubeL4/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l476xx.s
  group system
    ../system/src/: system_clock.c system_gpio.c system_spi.c system_uart.c system_it.c system.c system_time.c system_uart_retarget.c
  group display_touch
    ../display_touch/src/: display.c lv_port_disp.c semtech_logo.c
  group lvgl/lv_core
    ../external/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c lv_debug.c
  group lvgl/lv_draw
    ../external/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
  group lvgl/font
    ../external/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
  group lvgl/lv_hal
    ../external/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/lv_misc
    ../external/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c lv_printf.c
  group lvgl/objx
    ../external/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
  group lvgl/themes
    ../external/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lr1110_modem_driver
    ../lr1110_modem_driver/src/: lr1110_modem_system.c lr1110_modem_lorawan.c
  group lr1121_modem_driver
    ../lr1121_modem_driver/src/: lr1121_modem_modem.c
software components: Compiler:I/O:STDOUT 1.2.0
